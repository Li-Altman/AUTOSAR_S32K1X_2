<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="77D41648-439E-4E21-ABC5-0CA592498E29">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="BA159E93-0AE6-42BB-826D-F07AF2C2C791">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="017B3F49-EECF-4415-A4D8-07BD027AB37A">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="44EDDB59-B9F9-4F69-A2D6-FA9A6C9C5135">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F93F386C-8A71-47B9-83F3-1C9A66F8F97D">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="547D11B4-397C-46C9-A76F-CB96B565E6FD">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="B1320A99-98B9-469D-B629-5E3C44853AB1">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="89BD8E59-71EE-43C7-A7EE-A71133380917">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="93776E1C-DAFA-488C-A995-1DF3DE88F9C6">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2DF5C0B9-041B-4538-B287-6E169837CD92">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="97F395BA-E090-47E2-B76B-1DE25BC5EC96">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="29FE937A-F970-4731-9DD5-121E12E68C4B">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C9FD6CDA-0DA2-4ED8-9605-C4FCC8A9C208">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C97B11C1-7415-40B2-B591-9CC32565DCC3">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="77A2A7D0-87C3-4461-89B5-39B189A52B16">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="2AA88CAF-0107-4FA6-BA3E-21746078FAE5">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="52A4308B-6693-4FEE-992A-5F5FA2B536C8">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="1C1B11E6-9002-4995-892B-8D492BCAF664">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="ACE7A10C-750B-4FCA-BA1D-2E7D32CB2296">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="06A36852-217A-4788-9DBF-EBD935EE3C90">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B182F72C-E17E-44A1-8527-4625CEBAFF51">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="F4F6BF6D-A2EC-4B34-9E3D-097E4F8CF443">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="50D8CA4A-98AB-41A8-B361-AACFB2136AE4">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="983479EB-B51C-4D5C-9184-1B52327974F2">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="06A79EEA-23A4-47DA-967B-9C3F49758748">
      <SHORT-NAME>SwAddrMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AE275BD7-47EA-41CC-991B-FA962A7A670F">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="FE972B81-1535-4A7B-B49B-1612924D48BA">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="2C70FA3E-0E55-44AF-9988-0DB8444020FB">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C677B6C8-1599-4D71-A134-886DA82CF054">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="27158F2C-AD69-443E-9B74-B6C4FF1AAE03">
      <SHORT-NAME>VehicleProject</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3DE1A5B8-93DE-4659-8BD5-D7D2DE09EB0A">
      <SHORT-NAME>Diagnostics</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="553A8940-32D4-4859-99CF-2ECAD2DC6023">
      <SHORT-NAME>NM</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3FDE4955-53DF-4E00-9D4D-18AC0BA65712">
      <SHORT-NAME>TP</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6F95F049-9C61-49B8-BEBF-4F91A2122627">
      <SHORT-NAME>Cluster</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="29C2302A-E3AC-4185-AA79-823EF6280CC7">
      <SHORT-NAME>ECU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="80AB53AF-F3B5-4118-9483-BCF3961442B8">
      <SHORT-NAME>Gateway</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0F7BC303-27C9-48AE-BAD7-33CD5556D06C">
      <SHORT-NAME>IPDUGroup</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0FA68923-50F1-4564-B71C-85DC73E4D14C">
      <SHORT-NAME>CanFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DE57DF97-2226-47CD-BADA-E3AB534DDF5C">
      <SHORT-NAME>LinFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="405166DD-9323-40F5-A1AD-EA9C641208BD">
      <SHORT-NAME>FlexrayFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="93CD3D66-4131-4F08-957C-2DF3A4642B9D">
      <SHORT-NAME>PDU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9E3EDB89-C776-4CBD-BD20-A76AF816E5AB">
      <SHORT-NAME>ISignal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A9745496-020C-41C2-AECD-21D293FAF0E4">
      <SHORT-NAME>DataType</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="9A2AE580-C5AC-42FF-BC54-890A9332F41B">
          <SHORT-NAME>Constraint</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="01E6E50F-A066-4CFC-AE76-A56E3D8B039A">
          <SHORT-NAME>Semantics</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AED3096B-85FF-4D8F-8042-8F5E0E6B2DCB">
      <SHORT-NAME>Constant</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="743B01B7-0F4D-4BE8-AC88-A317160B864C">
      <SHORT-NAME>Signal</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>