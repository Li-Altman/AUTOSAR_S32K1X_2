# IAR project S32K1X_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K148 NXP S32K148
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: StartUp_Code; StartUp_Code\devices; StartUp_Code\devices\common; StartUp_Code\devices\S32K148\include; StartUp_Code\devices\S32K148\startup
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: START_FROM_FLASH; __NO_SYSTEM_INIT
  AARM.AUserIncludes: StartUp_Code
  ILINK.IlinkOutputFile: S32K1X_Project.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Linker_Files
    Linker_Files/: S32K148_256_flash.icf
  group StartUp_Code
    StartUp_Code/: startup_S32K148.S
  group StartUp_Code/devices
    StartUp_Code/devices/: callbacks.h devassert.h device_registers.h startup.c startup.h status.h
  group StartUp_Code/devices/S32K148/include
    StartUp_Code/devices/S32K148/include/: S32K148.h S32K148_features.h
  group StartUp_Code/devices/S32K148/startup
    StartUp_Code/devices/S32K148/startup/: system_S32K148.c system_S32K148.h
  group StartUp_Code/devices/common
    StartUp_Code/devices/common/: s32_core_cm4.h
