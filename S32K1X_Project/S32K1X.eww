<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\S32K1X_Project.ewp</path>
    </project>
    <batchBuild />
</workspace>
